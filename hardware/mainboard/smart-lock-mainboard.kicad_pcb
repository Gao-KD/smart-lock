# Repository Gao-KD/smart-lock (continued)

## KiCad design hardware/mainboard/smart-lock-mainboard.kicad_pcb (continued)

Parts:
BZ1: Buzzer; Buzzer_CUI_CPT-9019S-SMT; MPN CPT-9019S-SMT-TR; LCSC C95163
C50, C51, C52, C53, C54, C55: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D51, D52, D53, D54, D55: ESD5Z5.0T1G; D_SOD-523; MPN ESD5Z5.0T1G; LCSC C82044
D56: 1N4148W; D_SOD-123; MPN 1N4148W; LCSC C81598
D57: LED 红; LED_0603_1608Metric; MPN KT-0603R; LCSC C2286
D58: LED 绿; LED_0603_1608Metric; MPN 19-217/GHC-YR1S2/3T; LCSC C72043
D59: LED 蓝; LED_0603_1608Metric; MPN 19-217/BHC-ZL1M2RY/3T; LCSC C72041
D60: BAT54S; SOT-23; MPN BAT54S,215; LCSC C47546; not fitted
J4: FPC 16P 0.5mm; Hirose_FH12-16S-0.5SH_1x16-1MP_P0.50mm_Horizontal; MPN FH12-16S-0.5SH(55); LCSC C596731
J5: FINGERPRINT; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal; MPN SM06B-SRSS-TB(LF)(SN); LCSC C160405
J6: FACE; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal; MPN SM06B-SRSS-TB(LF)(SN); LCSC C160405; not fitted
Q4: MMBT3904; SOT-23; MPN MMBT3904; LCSC C20526
Q5: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R50, R52, R53, R54: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R56, R59: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R57, R58: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R60: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702; not fitted
SW1, SW2, SW3, SW4: PTS810; SW_SPST_PTS810; MPN PTS810SJM250SMTRLFS; LCSC C116501
SW5: PTS810; SW_SPST_PTS810; MPN PTS810SJM250SMTRLFS; LCSC C116501; not fitted
U5: DRV5032FBDBZR; SOT-23; MPN DRV5032FBDBZR; LCSC C2655033

Connections:
3V3: BZ1.1 (+), C50.1, D56.1 (K), D60.2 (K), J4.10, J5.6, R57.2, R58.2, U5.1 (VCC); also elsewhere on the board
3V3_FP: J5.1; also elsewhere on the board
3V3_NFC: J4.2; also elsewhere on the board
5V_FACE: J6.1; also elsewhere on the board
BUZZER: R50.1; also elsewhere on the board
BUZ_B: Q4.1 (B), R50.2
BUZ_N: BZ1.2 (-), D56.2 (A), Q4.3 (C)
DBL_LOCK: C51.1, D51.1 (K), SW1.1; also elsewhere on the board
DOOR_HALL: U5.2 (OUT); also elsewhere on the board
FACE_RX: D60.3 (COM), R60.2; also elsewhere on the board
FACE_RX_M: J6.3, R60.1
FACE_TX: J6.4; also elsewhere on the board
FP_RX: J5.3; also elsewhere on the board
FP_TOUCH: J5.5; also elsewhere on the board
FP_TX: J5.4; also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (A), J4.1, J4.9, J4.16, J4.MP (MountPin), J5.2, J6.2, Q4.2 (E), Q5.2 (S), R56.2, R59.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U5.3 (GND); also elsewhere on the board
KEY_BL: J4.14, Q5.3 (D)
KEY_BL_EN: Q5.1 (G), R56.1; also elsewhere on the board
KEY_INT: J4.13; also elsewhere on the board
KEY_SCL: J4.11, R57.1; also elsewhere on the board
KEY_SDA: J4.12, R58.1; also elsewhere on the board
LED_B: R54.1; also elsewhere on the board
LED_B_A: D59.2 (A), R54.2
LED_G: R53.1; also elsewhere on the board
LED_G_A: D58.2 (A), R53.2
LED_R: R52.1; also elsewhere on the board
LED_R_A: D57.2 (A), R52.2
MECH_KEY: C53.1, D53.1 (K), SW3.1; also elsewhere on the board
NFC_CS: J4.6; also elsewhere on the board
NFC_IRQ: J4.7; also elsewhere on the board
NFC_MISO: J4.5; also elsewhere on the board
NFC_MOSI: J4.4; also elsewhere on the board
NFC_NRST: J4.8, R59.1; also elsewhere on the board
NFC_SCK: J4.3; also elsewhere on the board
PROX_INT: J6.5; also elsewhere on the board
SETUP_KEY: C54.1, D54.1 (K), SW4.1; also elsewhere on the board
SPARE_WAKE: C55.1, D55.1 (K), J4.15, SW5.1; also elsewhere on the board
TAMPER: C52.1, D52.1 (K), SW2.1; also elsewhere on the board

Notes on the sheet:
开关输入均低有效：芯片内部上拉 + 数字滤波，板上每路 100 nF 到地 + ESD。 SW4（设置键）必须装在门内侧电池盒里；SW2（防撬）在面板被拆时动作；SW1/SW3 的安装位置按锁体结构定，也可改为线接。 SW5 为备用唤醒（SPARE_WAKE，同时引到 FPC 第 15 脚），默认不贴。 J6/R60/D60 为人脸版器件；人脸模组 UART 若为 5 V，FACE_RX 经 R60 串阻 + D60 钳位到 3V3，FACE_TX 3.3 V 直连（按模组手册核实）。

Board: 4 copper layers, 156 parts (0 on the bottom side), 101 nets, no tracks yet.

File hardware/mainboard/production/bom_full.csv (part):

Designator,Qty,Value,MPN,LCSC Part #,Footprint,Fitted,Sheet,Note
ANT1,1,433MHz spring,433 MHz 螺旋弹簧天线（手焊）,,smartlock:Spring_Antenna_433_THT,yes,射频,弹簧天线焊盘，板上沿
BZ1,1,Buzzer,CPT-9019S-SMT-TR,C95163,Buzzer_Beeper:Buzzer_CUI_CPT-9019S-SMT,yes,传感器与接口,无源蜂鸣器 2-3.2 kHz
C1,1,220uF/16V,RVT1C221M0607,C3342,Capacitor_SMD:CP_Elec_6.3x7.7,yes,电源,VBAT_P 储能 >=220uF，注意漏电流
"C2,C4",2,10uF/25V,CL21A106KAYNNNE,C15850,Capacitor_SMD:C_0805_2012Metric,yes,电源,
"C3,C17",2,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,电源,
"C5,C6",2,22uF/25V,CL21A226MAQNNNE,C45783,Capacitor_SMD:C_0805_2012Metric,yes,电源,
C7,1,47uF/10V,TAJB476K010RNJ,C22036,Capacitor_Tantalum_SMD:CP_EIA-3528-21_Kemet-B,yes,电源,3V3 储能，陶瓷+钽合计 >=47 uF
C8,1,1nF,CL05B102KB5NNNC,C14442,Capacitor_SMD:C_0402_1005Metric,yes,电源,CT：控制上升沿
"C9,C11",2,1uF,CL05A105KA5NQNC,C52923,Capacitor_SMD:C_0402_1005Metric,yes,电源,
C10,1,1nF,CL05B102KB5NNNC,C14442,Capacitor_SMD:C_0402_1005Metric,yes,电源,
C12,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,DNP,电源,
"C13,C14",2,22uF/25V,CL21A226MAQNNNE,C45783,Capacitor_SMD:C_0805_2012Metric,DNP,电源,
C15,1,10uF/25V,CL21A106KAYNNNE,C15850,Capacitor_SMD:C_0805_2012Metric,DNP,电源,
C16,1,10nF,CL05B103KB5NNNC,C15195,Capacitor_SMD:C_0402_1005Metric,DNP,电源,
C20,1,10uF,CL10A106KP8NNNC,C19702,Capacitor_SMD:C_0603_1608Metric,yes,主控,VREGVDD
C21,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,VREGVDD
C22,1,4.7uF,CL10A475KO8NNNC,C19666,Capacitor_SMD:C_0603_1608Metric,yes,主控,DVDD
C23,1,1uF,CL05A105KA5NQNC,C52923,Capacitor_SMD:C_0402_1005Metric,yes,主控,DECOUPLE
C24,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,IOVDD pad 6
C25,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,IOVDD pad 33
C26,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,IOVDD pad 54
C27,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,AVDD
C28,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,RFVDD
C29,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,PAVDD
C30,1,10uF,CL10A106KP8NNNC,C19702,Capacitor_SMD:C_0603_1608Metric,yes,主控,PAVDD bulk
C31,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,主控,
C40,1,10nF,CL05B103KB5NNNC,C15195,Capacitor_SMD:C_0402_1005Metric,yes,电机,
C41,1,10uF/25V,CL21A106KAYNNNE,C15850,Capacitor_SMD:C_0805_2012Metric,yes,电机,VM
C42,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,电机,VM
C43,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,电机,VCC
"C50,C51,C52,C53,C54,C55",6,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,传感器与接口,
C101,1,15pF,GRM1555C1H150JA01D,C76950,Capacitor_SMD:C_0402_1005Metric,yes,射频,官方 C1：公共节点对地，C0G ±5%
C102,1,5.6pF,GRM1555C1H5R6CA01D,C85941,Capacitor_SMD:C_0402_1005Metric,yes,射频,官方 C2：RX 串联，C0G ±0.25 pF
C105,1,220pF,GRM1555C1H221JA01D,C71693,Capacitor_SMD:C_0402_1005Metric,yes,射频,官方 C3：隔直/耦合，占原 L106 位（π 型串联位）
"C106,C107",2,DNP,,,Capacitor_SMD:C_0402_1005Metric,DNP,射频,π 型微调位，默认不贴
C108,1,100nF,CL05B104KO5NNNC,C1525,Capacitor_SMD:C_0402_1005Metric,yes,射频,L101 电源端就近去耦
C109,1,100pF,GRM1555C1H101JA01D,C77177,Capacitor_SMD:C_0402_1005Metric,yes,射频,L101 电源端就近去耦（高频）
C201,1,1pF,GJM0335C1E1R0BB01D,C91603,Capacitor_SMD:C_0201_0603Metric,yes,射频,AN1409 C1：TX 对地
C202,1,0.3pF,GJM0335C1ER30BB01D,C237456,Capacitor_SMD:C_0201_0603Metric,yes,射频,AN1409 C2：TX 对地
C203,1,DNP,,,Capacitor_SMD:C_0201_0603Metric,DNP,射频,天线端微调位，默认不贴
C204,1,20pF,GJM0335C1E200GB01D,C426116,Capacitor_SMD:C_0201_0603Metric,yes,射频,AN1409 C3（官方 19 pF，0201 无 19 pF 现货，用 20 pF ±2%；2.4 GHz 下为串联隔直，阻抗约 3 Ω，影响可忽略）
D1,1,BZT52C10,BZT52C10-7-F,C155227,Diode_SMD:D_SOD-123,yes,电源,Vgs 齐纳保护
D2,1,SMF5.0A,SMF5.0A-TP,C669056,Diode_SMD:D_SMF,yes,电源,VBUS TVS
D3,1,B5819W,B5819W-SL,C779676,Diode_SMD:D_SOD-123,yes,电源,USB 5V 经肖特基并入 VBAT_P
"D51,D52,D53,D54,D55",5,ESD5Z5.0T1G,ESD5Z5.0T1G,C82044,Diode_SMD:D_SOD-523,yes,传感器与接口,
D56,1,1N4148W,1N4148W,C81598,Diode_SMD:D_SOD-123,yes,传感器与接口,蜂鸣器反向续流
D57,1,LED 红,KT-0603R,C2286,LED_SMD:LED_0603_1608Metric,yes,传感器与接口,红灯，高有效
D58,1,LED 绿,19-217/GHC-YR1S2/3T,C72043,LED_SMD:LED_0603_1608Metric,yes,传感器与接口,绿灯，高有效
D59,1,LED 蓝,19-217/BHC-ZL1M2RY/3T,C72041,LED_SMD:LED_0603_1608Metric,yes,传感器与接口,蓝灯，高有效
D60,1,BAT54S,"BAT54S,215",C47546,Package_TO_SOT_SMD:SOT-23,DNP,传感器与接口,FACE_RX 钳位
J1,1,BAT 4xAA/2S,S2B-PH-SM4-TB(LF)(SN),C295747,Connector_JST:JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal,yes,电源,电池输入，1=正 2=负
J2,1,USB-C 供电,USB4125-GF-A,C3151650,Connector_USB:USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal,yes,电源,只供电：VBUS/GND/CC
J3,1,DEBUG 2x5 1.27,FTSH-105-01-L-DV,C5199898,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD,yes,主控,Mini Simplicity 兼容调试口
J4,1,FPC 16P 0.5mm,FH12-16S-0.5SH(55),C596731,Connector_FFC-FPC:Hirose_FH12-16S-0.5SH_1x16-1MP_P0.50mm_Horizontal,yes,传感器与接口,前后板 FPC，脚位按 board-spec 6.10
J5,1,FINGERPRINT,SM06B-SRSS-TB(LF)(SN),C160405,Connector_JST:JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal,yes,传感器与接口,1 3V3_FP 2 GND 3 模组TX(->PD3) 4 模组RX(<-PD2) 5 TOUCH_OUT 6 TOUCH_VCC；按模组线序调整
J6,1,FACE,SM06B-SRSS-TB(LF)(SN),C160405,Connector_JST:JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal,DNP,传感器与接口,1 5V_FACE 2 GND 3 模组TX 4 模组RX 5 PROX 6 备用；人脸版
J7,1,MOTOR,S2B-PH-SM4-TB(LF)(SN),C295747,Connector_JST:JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal,yes,电机,
J8,1,IPEX,BWIPX-1-001E,C496552,Connector_Coaxial:U.FL_Hirose_U.FL-R-SMT-1_Vertical,DNP,射频,IPEX/U.FL 座（预留）
L1,1,2.2uH,SWPA4020S2R2MT,C83423,Inductor_SMD:L_Sunlord_SWPA4020S,yes,电源,
L2,1,4.7uH,SWPA6045S4R7MT,C78804,Inductor_SMD:L_Sunlord_SWPA6045S,DNP,电源,
L3,1,2.2uH,LQM21PN2R2MGHL,C341781,Inductor_SMD:L_0805_2012Metric,yes,主控,DC-DC 电感，按参考设计核对
L101,1,10nH,LQG15HS10NJ02D,C77103,Inductor_SMD:L_0402_1005Metric,yes,射频,官方 L1：TX 馈电/匹配，接 PAVDD
L102,1,33nH,LQG15HS33NJ02D,C86062,Inductor_SMD:L_0402_1005Metric,yes,射频,官方 L2：TX 串联匹配
L103,1,82nH,LQG15HS82NJ02D,C98002,Inductor_SMD:L_0402_1005Metric,yes,射频,官方 L3：RX 对地
L201,1,3nH,LQP03TN3N0B02D,C98044,Inductor_SMD:L_0201_0603Metric,yes,射频,AN1409 L1：TX 串联
L202,1,8.2nH,LQP03TN8N2J02D,C206407,Inductor_SMD:L_0201_0603Metric,yes,射频,AN1409 L2：TX 串联
L203,1,3.1nH,LQP03TN3N1B02D,C206428,Inductor_SMD:L_0201_0603Metric,yes,射频,AN1409 L3：RX 串联到 50 Ω 节点
L204,1,1.8nH,LQP03TN1N8B02D,C98040,Inductor_SMD:L_0201_0603Metric,yes,射频,AN1409 L4：RX 对地
Q1,1,AO3401A,AO3401A,C15127,Package_TO_SOT_SMD:SOT-23,yes,电源,电池支路背靠背 P-MOS（电池侧）：防反接
Q2,1,AO3401A,AO3401A,C15127,Package_TO_SOT_SMD:SOT-23,yes,电源,分压高边开关
Q3,1,2N7002,2N7002,C8545,Package_TO_SOT_SMD:SOT-23,yes,电源,
Q4,1,MMBT3904,MMBT3904,C20526,Package_TO_SOT_SMD:SOT-23,yes,传感器与接口,
Q5,1,AO3400A,AO3400A,C20917,Package_TO_SOT_SMD:SOT-23,yes,传感器与接口,键盘背光低边
Q6,1,AO3401A,AO3401A,C15127,Package_TO_SOT_SMD:SOT-23,yes,电源,电池支路背靠背 P-MOS（负载侧）：插 USB 时关断，阻止反灌电池
Q7,1,2N7002,2N7002,C8545,Package_TO_SOT_SMD:SOT-23,yes,电源,电池正接且无 USB 时导通，拉低 Q1/Q6 栅极；电池装反时关断
Q8,1,2N7002,2N7002,C8545,Package_TO_SOT_SMD:SOT-23,yes,电源,USB 插入时导通，关断 Q7，从而关断电池支路
R1,1,10M,0402WGF1005TCE,C26082,Resistor_SMD:R_0402_1005Metric,yes,电源,默认关断上拉；10M 避免 Q7 导通时常耗电
"R2,R3",2,5.1k,0402WGF5101TCE,C25905,Resistor_SMD:R_0402_1005Metric,yes,电源,
R4,1,1M,0402WGF1004TCE,C26083,Resistor_SMD:R_0402_1005Metric,yes,电源,FB 分压：Vout = 0.6 V x (1 + R4/R5) = 3.31 V（按手册核实 Vref）
R5,1,221k,0402WGF2213TCE,C26998,Resistor_SMD:R_0402_1005Metric,yes,电源,
R6,1,0R,0402WGF0000TCE,C17168,Resistor_SMD:R_0402_1005Metric,yes,电源,S-CONF 配置电阻：按 TPS629210 数据手册表格选值（外部 FB、自动 PFM）
"R7,R8,R11,R13",4,100k,0402WGF1003TCE,C25741,Resistor_SMD:R_0402_1005Metric,yes,电源,上电默认关断
R9,1,100k,0402WGF1003TCE,C25741,Resistor_SMD:R_0402_1005Metric,DNP,电源,Vout = 0.8 V x (1 + R9/R10) = 4.99 V
R10,1,19.1k,0402WGF1912TCE,C52036,Resistor_SMD:R_0402_1005Metric,DNP,电源,
R12,1,100k,0402WGF1003TCE,C25741,Resistor_SMD:R_0402_1005Metric,yes,电源,
R14,1,1M,0402WGF1004TCE,C26083,Resistor_SMD:R_0402_1005Metric,yes,电源,VBAT = V(PB2) x 1330/330
R15,1,330k,0402WGF3303TCE,C25778,Resistor_SMD:R_0402_1005Metric,yes,电源,
R16,1,100k,0402WGF1003TCE,C25741,Resistor_SMD:R_0402_1005Metric,yes,电源,Q7 栅极由电池电压驱动（无直流耗电）
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
## Code that names these connections

File hardware/mainboard/tools/gen_project.py (part):

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    ("18", "RESETn", "input"), ("16", "HFXTAL_I", "passive"), ("17", "HFXTAL_O", "passive"), None,
    ("23", "SUBG_O1", "passive"), ("21", "SUBG_I1", "passive"),
    ("24", "RF2G4_O0", "passive"), ("22", "RF2G4_I0", "passive"), None,
    ("2", "PD00/LFXTAL_O", "bidirectional"), ("1", "PD01/LFXTAL_I", "bidirectional"),
]
PAD = {  # GPIO -> pad
    "PA00": "32", "PA01": "34", "PA02": "35", "PA03": "36", "PA04": "37", "PA05": "38", "PA06": "39",
    "PA07": "40", "PA08": "41", "PA09": "42", "PA10": "43", "PA11": "44", "PA12": "45", "PA13": "46",
    "PA14": "47", "PB00": "31", "PB01": "30", "PB02": "29", "PB03": "28", "PB04": "27", "PB05": "26",
    "PC00": "3", "PC01": "4", "PC02": "5", "PC03": "7", "PC04": "8", "PC05": "9", "PC06": "10",
    "PC07": "11", "PC08": "12", "PC09": "13", "PC10": "14", "PC11": "15",
    "PD02": "68", "PD03": "67", "PD04": "66", "PD05": "65", "PD06": "64", "PD07": "63", "PD08": "62",
    "PD09": "61", "PD10": "60", "PD11": "59", "PD12": "58", "PD13": "57", "PD14": "56", "PD15": "55",
}
EFR_RIGHT = []
for port, rng in (("A", range(15)), ("B", range(6)), ("C", range(12)), ("D", range(2, 16))):
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        "U2 的 MODE/S-CONF（R6）和 FB/VSET 接法、U8 的 RT 悬空频率请按 TI 数据手册核实。\n"
        "C1 选低漏电型号：电解电容漏电可能达数 µA~数十 µA，打样后实测睡眠电流，必要时换陶瓷电容组。", 15, 235)

P.part(sp, "J1", "Connector_Generic_MountingPin:Conn_01x02_MountingPin", "BAT 4xAA/2S",
       "Connector_JST:JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal",
       {"1": "BAT", "2": "GND", "MP": None}, "C295747", "S2B-PH-SM4-TB(LF)(SN)", note="电池输入，1=正 2=负")
P.part(sp, "Q1", "Transistor_FET:AO3401A", "AO3401A", "Package_TO_SOT_SMD:SOT-23",
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P.part(sp, "Q3", "Transistor_FET:2N7002", "2N7002", "Package_TO_SOT_SMD:SOT-23",
       {"1": "VBAT_EN", "2": "GND", "3": "VDIV_G"}, "C8545", "2N7002")
R(sp, "R13", "100k", "VBAT_EN", "GND", note="上电默认关断")
R(sp, "R14", "1M", "VDIV_HI", "VBAT_ADC", note="VBAT = V(PB2) x 1330/330")
R(sp, "R15", "330k", "VBAT_ADC", "GND")
C(sp, "C17", "100nF", "VBAT_ADC")
for i, n in enumerate(["BAT", "USB_VBUS", "VBAT_P", "3V3", "5V_FACE", "GND"]):
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        "QFN68 封装选 EP 5.2x5.2 mm 版本，请按数据手册封装图核对散热焊盘尺寸。\n"
        "J3 引脚按 Mini Simplicity 10 针（AN958）定义：1 VTARGET 2 GND 3 RST 4 VCOM_RX 5 VCOM_TX 6 SWO 7 SWDIO 8 SWCLK 9/10 PTI 不用。", 15, 235)
G = {  # GPIO -> signal, exactly board-spec section 3 / board.h
    "PA00": "KEY_INT", "PA01": "SWCLK", "PA02": "SWDIO", "PA03": "SWV", "PA04": "NFC_IRQ",
    "PA05": "SETUP_KEY", "PA06": "FP_TOUCH", "PA07": "DOOR_HALL", "PA08": "VCOM_TX", "PA09": "VCOM_RX",
    "PA10": "PROX_INT", "PA11": "MECH_KEY", "PA12": "KEY_SCL", "PA13": "KEY_SDA", "PA14": "BUZZER",
    "PB00": "DBL_LOCK", "PB01": "TAMPER", "PB02": "VBAT_ADC", "PB03": "SPARE_WAKE",
    "PB04": "MOT_ISENSE", "PB05": "LED_R",
    "PC00": "NFC_SCK", "PC01": "NFC_MOSI", "PC02": "NFC_MISO", "PC03": "NFC_CS", "PC04": "NFC_NRST",
    "PC05": "NFC_PWR_EN", "PC06": "MOT_IN1", "PC07": "MOT_IN2", "PC08": "MOT_NSLEEP",
    "PC09": "VBAT_EN", "PC10": "LED_G", "PC11": "LED_B",
    "PD00": "LFXTAL_O", "PD01": "LFXTAL_I", "PD02": "FP_TX", "PD03": "FP_RX", "PD04": "FP_PWR_EN",
    "PD05": "FACE_PWR_EN", "PD06": "FACE_TX", "PD07": "FACE_RX", "PD08": "KEY_BL_EN",
}
for i in range(9, 16):
    G["PD%02d" % i] = "TP_PD%d" % i
upins = {"50": "3V3", "49": "VREGSW", "51": "GND", "52": "DVDD", "48": "DECOUPLE", "53": "3V3",
         "6": "3V3", "33": "3V3", "54": "3V3", "19": "3V3", "25": "PAVDD", "20": "GND", "69": "GND",
         "18": "RESETn", "16": "HFXI", "17": "HFXO", "23": "SUBG_O1", "21": "SUBG_I1",
         "24": "RF2G4_O0", "22": "RF2G4_I0", "2": "LFXTAL_O", "1": "LFXTAL_I"}
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
# ================================================================== sheet 4: motor
so = P.sheet("电机", "motor.kicad_sch", "电机：DRV8837 + 0.22 Ω 低边电流采样", paper="A4")
so.text("VM 直接接 VBAT_P；低边 0.22 Ω 采样（MOT_GND），经 1k/10nF 到 PB4。\n"
        "大电流回路（J7、U3、R30、C41）远离射频和晶振，电机地单点回到电池负极。\n"
        "U3 散热焊盘 EP 与 GND 脚同接 MOT_GND。", 15, 150)
P.part(so, "U3", "Driver_Motor:DRV8837", "DRV8837DSGR", "Package_SON:WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm",
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