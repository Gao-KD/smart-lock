# Repository Gao-KD/smart-lock

File README.md:

# smart-lock

面向高校宿舍、公租房等批量管理场景的智能门锁系统：门锁主板固件、楼宇网关、每校私有化部署的管理平台。

- 门锁：单芯片 EFR32FG28（Sub-GHz + BLE），标准 24×240 锁体，4 节 AA 供电
- 空口：433 MHz 私有协议，“同步唤醒”：网关不发信标、只在有数据时发射，门锁每秒在自己的时隙嗅探约 1 ms 前导码，靠加密 ACK 对齐和校时，带防假前导码耗电保护；AES-128-CCM* 两层加密——见 **[docs/radio-plan.md](docs/radio-plan.md)**
- 网关：每 6–7 层一台，Linux 主机 + 3–4 路射频协处理器，以太网或 4G 回传
- 平台：MQTT 5（TLS）+ 指令下发服务，每所学校独立私有化部署
- 时延目标：单条指令 P99 ≤ 1.5 s 到锁；单网关约 270 把锁约 2 s 全部送达；广播 1 s 内全楼送达
- 门锁功能：校园卡、密码（虚位/一次性/周期）、离线密码、手机蓝牙钥匙、成员冻结与退宿、试错冻结/胁迫/防撬/门未关等告警、室内反锁与门磁、访客呼叫确认后远程开门、参数配置、开门记录补传——见 **[docs/lock-features.md](docs/lock-features.md)**
- 出厂与绑定：未绑定时体验模式（123456/任意卡/指纹/人脸）、网关批量绑定与安装师傅蓝牙绑定、两阶段提交 + A/B 密钥槽保证断电断连不变砖、授权恢复出厂——见 **[docs/provisioning.md](docs/provisioning.md)**
- 连接策略：同步唤醒（一直可达）、事件即时上报 + ACK 重发、30 分钟心跳上报电量与状态（平台不轮询）、断线探测与重连、入网退避、ACK 校时、断网本地开门——见 **[docs/connectivity.md](docs/connectivity.md)**

## 模拟演示平台（在电脑上跑整套系统）

360 把虚拟门锁（运行门锁固件的真实 C 代码）+ 模拟 433MHz 空口 + 2 台网关 + 平台 + Web 控制台，20 个功能各有一键演示：

```sh
docker compose -f deploy/sim/docker-compose.yml up --build   # 或者本机: scripts/sim.sh
# 打开 http://localhost:8080 ，另开终端:
scripts/demo.sh all                                          # Docker: docker compose -f deploy/sim/docker-compose.yml exec sim demo all
```

详细说明、功能演示清单、在线画板/仿真工具对比见 **[docs/simulator.md](docs/simulator.md)**。

## 目录

| 目录 | 内容 | 语言 |
| --- | --- | --- |
| `common/slp` | 空口协议库：帧编解码、CRC、CCM nonce、防重放、发送计数器、消息去重、应用 TLV、时隙计算、两层加密封装；`port/host` 为 PC 用的 AES-128-CCM* 实现 | C99 |
| `common/slpgo` | 同一协议的 Go 实现（网关、平台使用，与 C 版互通测试）+ 模拟平台约定 | Go |
| `firmware/lock` | 门锁固件：锁状态机（含反锁、门磁）、凭证库（校园卡只读卡号、密码、周期/次数/冻结）、离线密码、蓝牙令牌、告警与记录日志、命令处理、锁端 MAC（ACK 同步、假唤醒防护、失联重连、上行确认重发）、硬件抽象 | C99 |
| `firmware/lock/port/efr32` | EFR32FG28 移植层：定稿引脚表 `board.h`、板级驱动、PSA 加密、板级自检程序（射频/蓝牙/模组驱动待实现，见该目录 README） | C |
| `firmware/lock/port/sim` | 模拟平台：locksim（数百把虚拟锁 + 模拟空口 + 模拟射频协处理器） | C |
| `firmware/rcp` | 网关射频协处理器固件（待实现） | C |
| `gateway` | 网关主机程序：入网、锁表与信道/时隙分配、按周期的优先级调度、周期内插入紧急指令、链路层加密与防重放、上行 ACK、MQTT 桥接 | Go |
| `platform` | 私有化平台：指令下发服务（HTTP 开放接口、按网关分批、三段确认、离线补发）、上行解密与去重、记录缺口补传、离线密码/蓝牙钥匙签发、Web 控制台、功能演示程序、docker-compose 部署 | Go |
| `deploy/sim`、`scripts` | 模拟平台一键启动（Docker / 本机脚本）与功能演示 | |
| `proto/gateway/v1` | 网关与平台之间的消息定义 | Protobuf |

## 硬件

- **[主板设计规格 rev A](docs/hardware/board-spec.md)**：可直接画板的电源树、定稿引脚表、各模块参考电路、FPC 定义、BOM、检查清单
- **[主板 KiCad 8 工程](hardware/mainboard/README.md)**：按规格生成的分层原理图、封装、嘉立创 BOM（带 LCSC 编号）、导入网表的 4 层空板；ERC 0 违规，引脚与 `board.h` 逐脚核对
- [macOS 上用 KiCad 画板并在嘉立创下单](docs/hardware/kicad-macos.md)
- **[硬件交付说明](docs/hardware/handoff.md)****：给硬件工程师的平台选型、BOM 与频段采购、接口约束、软硬件分工、验收标准（含频段合规风险）
- [EFR32 移植层说明](firmware/lock/port/efr32/README.md)：固件怎么编译、烧录，哪些已完成
- [测试购买清单](docs/hardware/purchase-list.md)
- [嘉立创 EDA 原理图与 PCB 指南](docs/hardware/pcb-guide.md)

## 构建与测试

```sh
# 协议库 + 门锁固件逻辑（主机上编译，用模拟硬件跑单元测试）
cmake -S . -B build && cmake --build build -j && ctest --test-dir build --output-on-failure
./build/firmware/lock_host_demo

# Go：协议库、网关、平台的单元测试
(cd common/slpgo && go test ./...) && (cd gateway && go test ./...) && (cd platform && go test ./...)

# 只看网关调度（不需要 MQTT 和门锁）
cd gateway && go run ./cmd/gateway -dry-run -locks 270 -channels 3

# 整套系统：见上面“模拟演示平台”
```

## 现状

协议格式、锁状态机、全部门锁功能（见 [lock-features.md](docs/lock-features.md)）、连接策略（见 [connectivity.md](docs/connectivity.md)）、两层加密、网关调度与 MQTT 桥接、平台下发与上行处理已实现并有测试，并能在模拟平台上端到端运行。以下尚未实现：

- EFR32 移植：板级驱动（GPIO、ADC、电机、NVM3、开关输入）和 PSA 加密已写好但只过了语法检查，未在 Simplicity SDK 中编译、未上板；RAIL 收发、BLE 协议栈与蓝牙钥匙挑战应答、FM17550/键盘/指纹/人脸驱动、主循环、OTA 待实现
- 网关射频协处理器串口驱动、持久化队列、入网 K_dev 校验（模拟平台里用 UDP 代替串口）
- 平台数据库、密钥服务（KMS）、鉴权（模拟平台里用内存和模拟密钥代替）
- 指纹/人脸模组驱动、OTA、日志拉取

## KiCad design hardware/mainboard/smart-lock-mainboard.kicad_pcb

File hardware/mainboard/README.md:

# 门锁主板 rev A：KiCad 8 工程

按 [docs/hardware/board-spec.md](../../docs/hardware/board-spec.md) 生成的门锁后面板主板 KiCad 工程。原理图连接与规格第 3 节引脚表、[`firmware/lock/port/efr32/board.h`](../../firmware/lock/port/efr32/board.h) 一一对应，板子照此做出来就能直接跑仓库里的固件。macOS 上安装 KiCad、导出生产文件、在嘉立创下单的步骤见 [docs/hardware/kicad-macos.md](../../docs/hardware/kicad-macos.md)。

## 目录

| 文件 | 内容 |
| --- | --- |
| `smart-lock-mainboard.kicad_pro` | 工程文件，用 KiCad 打开它。已设好网络类（Power 0.5 mm、RF、Default 0.15 mm）和嘉立创工艺下的最小线宽线距 |
| `smart-lock-mainboard.kicad_sch` | 顶层原理图，下挂 5 张分页图 |
| `power.kicad_sch` | 电源：电池/USB-C、防反接、3V3 降压、负载开关、5V（人脸版）、电池采样 |
| `mcu.kicad_sch` | 主控：EFR32FG28、去耦、DC-DC 电感、39 MHz / 32.768 kHz 晶振、复位、调试口、测试点 |
| `rf.kicad_sch` | 射频：433 MHz 匹配/低通/π 型微调/天线选择，2.4 GHz 匹配 + PCB 天线 |
| `motor.kicad_sch` | 电机：DRV8837、0.22 Ω 电流采样 |
| `io.kicad_sch` | 门磁、开关、蜂鸣器、RGB 灯、前面板 FPC、指纹/人脸接口 |
| `smart-lock-mainboard.kicad_pcb` | 4 层空板：所有封装已导入并带网络，停放在板框右侧，按分页分组。布局布线由你来做 |
| `lib/` | 工程库：EFR32FG28、TPS629210、DRV5032、各电源符号；433 弹簧天线焊盘封装 |
| `production/bom_jlcpcb.csv` | 嘉立创 SMT 格式 BOM（Comment, Designator, Footprint, LCSC Part #），不含 DNP 件 |
| `production/bom_full.csv` | 完整 BOM：型号、LCSC、封装、是否贴、所在页、备注（含 DNP 件） |
| `production/schematic.pdf` | 原理图 PDF，方便不开 KiCad 时审阅 |
| `production/erc.rpt` | ERC 报告 |
| `tools/` | 生成和校验脚本（见文末） |

前面板小板（FM17550 读卡、触摸键盘控制器）不在本工程内，经 J4（16 针 FPC）连接，脚位按规格 6.10 节。

## 已验证

- **ERC**：KiCad 8.0.9 `kicad-cli sch erc --severity-all`，0 个违规（含警告）。
- **引脚表**：从网表反查 U1 每个焊盘的网络，`board.h` 里 37 个信号 + SWD/LFXO 固定脚全部落在正确焊盘上（`tools/check_netlist.py`）。
- **QFN68 焊盘编号**：取自 Silicon Labs 官方 pin tool 数据 `EFR32FG28B322F1024IM68.device`（sisdk-release 仓库）。注意 B322（带 2.4 GHz）和 B320 的 22、24 脚不同：B322 是 RF2G4_I0 / RF2G4_O0，433 MHz 走 SUBG_I1（21）/ SUBG_O1（23）。
- **PCB 与原理图一致**：`kicad-cli pcb drc --schematic-parity`，0 个差异。之后改原理图，在 PCB 里按 F8（从原理图更新 PCB）即可同步。
- **TPS629210 引脚**：两份独立的厂商符号库交叉核对一致。DRV5032 引脚同样核对过。

## 打板前必须补的地方

生成环境里拿不到 Silicon Labs 和 TI 的设计文件，下面这些在原理图上都有文字标注，请对照官方资料补齐：

1. **433 MHz 匹配网络**：已按项目方提供的 Direct-Tie 方案填好（依据 EFR32ZG28 数据手册 5.2.3 Fig 5.7 / Table 5.5 和 AN923.2 的 +14 dBm 网络，见下节）。生成时拿不到原文，打样前请对照数据手册再确认一遍取值和连接。2.4 GHz 匹配已按 AN1409 Figure 1.2 / Table 1.2 填好（见“2.4 GHz 匹配”一节）。原理图里已经没有 TBD 件。
2. **主控去耦和 DC-DC 电感**：mcu 页用的是 Series 2 常见取值（VREGVDD 10 µF + 100 nF，DVDD 4.7 µF，DECOUPLE 1 µF，各电源脚 100 nF，L3 2.2 µH），按 BRD4401C 核对。
3. **QFN68 散热焊盘尺寸**：封装选了 KiCad 库的 `QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm_ThermalVias`，请按数据手册封装图核对 EP 尺寸（库里另有 EP 6.4 mm 版本）。
4. **U2 TPS629210 配置**：R6（MODE/S-CONF）和 FB/VSET 的接法要按数据手册的配置表确认（目标：外部分压反馈、自动 PFM）。R4/R5 = 1 MΩ / 221 kΩ 对应 Vref 0.6 V 时 3.31 V。
5. **U8 TPS62933（人脸版，默认不贴）**：RT 脚悬空的默认频率、关断电流是否满足规格 ≤ 1 µA。
6. **39 MHz 晶振**：Y1 选了 TXC 8Y39072005（2016 封装），频率、负载电容和精度按参考设计核对。
7. **C1 漏电流**：VBAT_P 上 220 µF 电解电容的漏电可能有几 µA 到几十 µA，会吃掉睡眠功耗预算。打样后实测睡眠电流，必要时换成陶瓷电容组或低漏电聚合物电容。

### 433 MHz 匹配（Direct-Tie，无射频开关）

```
PAVDD ── L101 10nH ──────────────────┐
SUBG_O1 ────────────────────────────┴── L102 33nH ──┬── C105 220pF ── RF_ANT ── R101 0R ── ANT1
                                                    ├── C101 15pF ── GND
SUBG_I1 ──┬── C102 5.6pF ───────────────────────────┘
          └── L103 82nH ── GND
C106（RF_SUBG 对地）、C107（RF_ANT 对地）：π 型微调位，默认不贴；L101 电源端就近 C109 100pF + C108 100nF
```

| 位号 | 官方位号 | 值 | 型号 | LCSC | 核对 |
| --- | --- | --- | --- | --- | --- |
| L101 | L1 | 10 nH | LQG15HS10NJ02D | C77103 | 一致 |
| L102 | L2 | 33 nH | LQG15HS33NJ02D | C86062 | 一致 |
| L103 | L3 | 82 nH | LQG15HS82NJ02D | C98002 | 一致 |
| C101 | C1 | 15 pF C0G | GRM1555C1H150JA01D | **C76950** | 方案里写 C127924，按型号查到的是 C76950 |
| C102 | C2 | 5.6 pF C0G | GRM1555C1H5R6CA01D | C85941 | 一致 |
| C105 | C3 | 220 pF C0G | GRM1555C1H221JA01D | C71693 | 一致 |
| C109 | — | 100 pF C0G | GRM1555C1H101JA01D | C77177 | 新增：L101 电源端高频去耦 |

“核对”一栏是按型号在 LCSC 料号库镜像里反查的结果。以立创商城页面为准，下单前请再看一眼库存。方案里另外给的几个替代料号也对不上，所以没有用：风华 0402CG150J500NT 查到的是 C1548（不是 C1644）；三星 CL05C221JB5NNNC 查到的是 C307445（不是 C1603）；国巨 RC0402JR-070RL 查到的是 C60485，而 C17168 实际是 UniOhm 0402WGF0000TCE。R101 仍用 C17168。

说明：

- C3 放在原 L106 的位置，位号改成 C105（原来的隔直电容 C105 已删除），这样电容不会挂着 L 开头的位号。原来的 L104、L105、C103、C104 也已删除。
- L101 的馈电接 PAVDD 网络，供电方式见下面“PAVDD 供电”一节。门锁按 10 mW e.r.p. 限值设计，+14 dBm 匹配够用，固件按天线实测增益设定传导功率，不要满功率发射。
- 只有一级 LC，二、三次谐波余量比原来少，送检前用频谱仪确认。

### 2.4 GHz 匹配（AN1409 Figure 1.2 / Table 1.2，10 dBm，PAVDD 1.8 V）

```
RF2G4_O0 ── L201 3nH ──┬── L202 8.2nH ──┬── C204 20pF ──┬── RF24_ANT ── ANT2（PCB 天线）
                       C201 1pF         C202 0.3pF      │
                       GND              GND             │
RF2G4_I0 ──┬── L203 3.1nH ──────────────────────────────┘
           L204 1.8nH ── GND
C203（RF24_ANT 对地）：微调位，默认不贴
```

| 位号 | AN1409 | 值 | 型号（0201） | LCSC |
| --- | --- | --- | --- | --- |
| L201 | L1 | 3 nH | LQP03TN3N0B02D | C98044 |
| L202 | L2 | 8.2 nH | LQP03TN8N2J02D | C206407 |
| L203 | L3 | 3.1 nH | LQP03TN3N1B02D | C206428 |
| L204 | L4 | 1.8 nH | LQP03TN1N8B02D | C98040 |
| C201 | C1 | 1 pF | GJM0335C1E1R0BB01D | C91603 |
| C202 | C2 | 0.3 pF | GJM0335C1ER30BB01D | C237456 |
| C204 | C3 | **20 pF**（官方 19 pF） | GJM0335C1E200GB01D | C426116 |

- 拓扑和取值按项目方提供的 AN1409 图 1.2 截图核对过。
- 这一路照官方用 0201：在 2.4 GHz，0402 焊盘的寄生参数会让 0.3 pF、1.8 nH 这类小值偏离。嘉立创能贴 0201，但手工返修比较难。
- 19 pF 没有查到 0201 现货，所以用 20 pF ±2%。它在电路里是串联隔直电容，2.4 GHz 下阻抗约 3 Ω，差 1 pF 影响可以忽略。
- LCSC 编号按型号在料号库镜像里查到，以立创商城页面为准。

### PAVDD 供电：0Ω 二选一，默认 1.8 V

PAVDD（U1 第 25 脚，同时给 433 MHz 的 L101 馈电）是单独的 `PAVDD` 网络，经两个 0402 0Ω 位二选一：

- **R21（默认贴）**：接 DVDD，也就是片内 DC-DC 经 L3 输出的约 1.8 V。这和 AN1409 2.4 GHz 取值的条件一致，433 MHz 的 +14 dBm 匹配也按低压 PA 供电设计，发射时更省电。
- **R22（默认不贴）**：接 3V3。只有需要更高发射功率时才用，而且两路匹配都要重新调。

需要核实：PAVDD 改由 DC-DC 供电后，发射电流也走 DC-DC 和 L3。请按 xG28 数据手册确认 DC-DC 的负载能力，以及 L3（LQM21PN2R2MGHL）的额定电流。打样后，在 433 MHz 和 BLE 发射时测一下 DVDD 的跌落。

### USB 供电反灌电池：已改为背靠背 MOS + USB 检测

原来的问题是：插 USB-C 时 Q1 导通，电流会从 VBAT_P 反灌进电池。现在电池支路是两颗背靠背 P-MOS（Q1 电池侧、Q6 负载侧，源极相接于 BAT_SRC，栅极共接 REVPOL_G）。只串一颗背靠背 MOS 而栅极仍然接地，两颗都会导通，挡不住反灌，所以加了栅极控制：

- **只有电池**：R16 把电池电压送到 Q7 栅极 → Q7 导通，把 REVPOL_G 拉低 → Q1/Q6 导通，电池供电。
- **插 USB**：USB_VBUS 打开 Q8 → Q7 栅极被拉低、Q7 关断 → R1（10 MΩ）把栅极拉到源极 → Q1/Q6 关断。两颗管子的体二极管方向相反，电流两个方向都过不去，VBAT_P 只由 USB 经 D3 供电。
- **电池装反**：Q7 栅极为负、Q7 关断，Q1/Q6 关断，体二极管也不导通。

代价：
- 电池通路多一颗 MOS，导通电阻约为原来的 2 倍（两颗 AO3401A 串联约 0.1 Ω），超过规格写的 ≤ 50 mΩ。电机堵转 450 mA 时压降约 50 mV。在意的话两颗都换成更低 Rds(on) 的 P-MOS。
- 插 USB 期间，电池经 R16 → Q8 有约 60–84 µA 电流，只在应急供电时出现。不插 USB 时，这部分电路没有直流耗电（R1 两端同电位，R16 只接栅极）。
- 规格已同步：`docs/hardware/board-spec.md` 第 1、2、6.9、7 节。

## 默认不贴（DNP）的器件

- 人脸版：U8、L2、C12–C16、R9、R10、J6、R60、D60
- 天线二选一：R102、J8（默认贴 R101 接弹簧天线 ANT1；改用 IPEX 时贴 R102 + J8、拆 R101）
- 433 MHz π 型微调位 C106、C107，2.4 GHz 微调位 C203
- PAVDD 接 3V3 的跳线 R22（默认贴 R21 接 1.8 V）
- 备用开关 SW5

改成人脸版：在原理图里选中这些符号，属性里取消“不贴装（DNP）”，再重新导出 BOM。

ANT1（433 MHz 弹簧天线）没有嘉立创编号，需要手焊，不在 `bom_jlcpcb.csv` 里。U1 嘉立创可能没货，可选“客供料”或先在嘉立创元件库下单备货。

## PCB 布局要点

**叠层**：4 层 1.6 mm，L1 信号 + 射频、L2 完整地（不要切割）、L3 电源（3V3 / VBAT_P 铺铜）、L4 信号。嘉立创下单选“阻抗控制”，叠层用常用的 JLC04161H-7628。50 Ω 共面波导的参考值是 0.30 mm 线宽、0.20 mm 到地间距（`RF` 网络类已设 0.30 mm），地铜边缘每隔 1.5–2 mm 打一个地过孔。这个参考值是项目方提供的，没有核实，请用嘉立创阻抗计算器按这个叠层复核。

**先放射频和主控**：

- U1 放在板子上半部，射频脚（21–24）朝板子上沿。
- 433 MHz 匹配元件按原理图顺序排成一条直线，紧贴 SUBG_O1 / SUBG_I1，走线尽量短，不拐直角，两侧打一排地过孔。L101 的电源端就近放 C108/C109。π 型（C106/C105/C107）放在天线馈点旁边。
- **天线净空**：ANT1 弹簧天线放在板子上沿，离电池仓和电机至少 15 mm；焊盘周围 5 mm 内所有层（Top/L2/L3/Bottom）都不铺铜。2.4 GHz PCB 天线（ANT2，倒 F 形状）放在板角，天线区域所有层都不铺铜、不走线，形状最好照抄 BRD4401C。
- Y1（39 MHz）紧贴 HFXTAL_I/O（16、17 脚），下方和周围不走其他信号线，周边铺地；Y2 紧贴 PD0/PD1。
- U1 散热焊盘的封装已带 25 个地过孔（规格要求 9–16 个，可按工艺删减）；去耦电容按“每个电源脚一个 100 nF、离脚最近”放。DC-DC 电感 L3 和 C22 紧贴 VREGSW/DVDD。

**电源走线**：

- J1 → Q1 → VBAT_P 主干、电机回路（J7、U3、R30）走 0.5 mm 以上（`Power` 网络类已设好），能铺铜就铺铜。
- U2 降压的高频回路要小：C4 紧贴 VIN/GND，L1 紧贴 SW，SW 节点铜皮尽量小；R4/R5 是 1 MΩ 级高阻节点，FB 走线要短，远离 SW 和电感。
- **电机地单点接地**：电机电流经 R30 回到 GND，R30 的 GND 端直接接到 J1 负极附近，不要让电机电流穿过射频和主控下方的地。MOT_ISENSE 从 R30 的 MOT_GND 端开尔文引出，经 R31/C40 送到 U1。
- 电机驱动和大电流走线远离射频、晶振和天线。
- 空白处铺地，各层地多打缝合过孔，射频区域加密。

**接口和机械**：

- J4（FPC）放在朝前面板穿线孔的一边；J5/J6 靠近指纹、人脸模组走线方向。
- SW4（设置键）必须在门内侧电池盒里能按到；SW2（防撬）放在面板被拆时会动作的位置；SW1/SW3 按锁体结构定，也可以改成线接。
- J3 调试口和 TP1–TP16 测试点放在板边，方便产测顶针。
- 板框现在是 70 × 50 mm 占位矩形，按拆机量好的后面板内腔尺寸替换，标好螺丝孔、电池仓、电机线、把手方轴位置。最后看 3D 预览，检查元件高度。

## 重新生成

改连接请改 `tools/gen_project.py`（同时改规格和 `board.h`），然后运行：

```bash
cd hardware/mainboard
docker run --rm -v "$PWD/../..":/repo -w /repo/hardware/mainboard kicad/kicad:8.0 tools/build.sh
```

脚本依次生成原理图、跑 ERC、核对网表和引脚表、生成 PCB、跑原理图/PCB 一致性检查、导出 PDF。**注意**：重新生成会覆盖原理图和 PCB，开始手工布局之后就不要再跑它，直接在 KiCad 里改。

Notes on the sheet:
门锁后面板主板 rev A。规格：docs/hardware/board-spec.md；固件引脚：firmware/lock/port/efr32/board.h。 本工程由 tools/gen_project.py 生成。连线用全局标签，原理图可自行整理排版，改连接请同时改规格和 board.h。 前面板小板（FM17550 读卡、触摸键盘控制器）不在本工程内，经 J4 FPC 连接。

Parts:
C1: 220uF/16V; CP_Elec_6.3x7.7; MPN RVT1C221M0607; LCSC C3342
C2, C4: 10uF/25V; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C3, C17: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C5, C6: 22uF/25V; C_0805_2012Metric; MPN CL21A226MAQNNNE; LCSC C45783
C7: 47uF/10V; CP_EIA-3528-21_Kemet-B; MPN TAJB476K010RNJ; LCSC C22036
C8, C10: 1nF; C_0402_1005Metric; MPN CL05B102KB5NNNC; LCSC C14442
C9, C11: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C12: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525; not fitted
C13, C14: 22uF/25V; C_0805_2012Metric; MPN CL21A226MAQNNNE; LCSC C45783; not fitted
C15: 10uF/25V; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850; not fitted
C16: 10nF; C_0402_1005Metric; MPN CL05B103KB5NNNC; LCSC C15195; not fitted
D1: BZT52C10; D_SOD-123; MPN BZT52C10-7-F; LCSC C155227
D2: SMF5.0A; D_SMF; MPN SMF5.0A-TP; LCSC C669056
D3: B5819W; D_SOD-123; MPN B5819W-SL; LCSC C779676
J1: BAT 4xAA/2S; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN); LCSC C295747
J2: USB-C 供电; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal; MPN USB4125-GF-A; LCSC C3151650
L1: 2.2uH; L_Sunlord_SWPA4020S; MPN SWPA4020S2R2MT; LCSC C83423
L2: 4.7uH; L_Sunlord_SWPA6045S; MPN SWPA6045S4R7MT; LCSC C78804; not fitted
Q1, Q2, Q6: AO3401A; SOT-23; MPN AO3401A; LCSC C15127
Q3, Q7, Q8: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1: 10M; R_0402_1005Metric; MPN 0402WGF1005TCE; LCSC C26082
R2, R3: 5.1k; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R4, R14: 1M; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
R5: 221k; R_0402_1005Metric; MPN 0402WGF2213TCE; LCSC C26998
R6: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
R7, R8, R11, R12, R13, R16, R17: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R9: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741; not fitted
R10: 19.1k; R_0402_1005Metric; MPN 0402WGF1912TCE; LCSC C52036; not fitted
R15: 330k; R_0402_1005Metric; MPN 0402WGF3303TCE; LCSC C25778
TP1: 3V3; TestPoint_Pad_D1.0mm
TP2: VBAT_P; TestPoint_Pad_D1.0mm
TP3: GND; TestPoint_Pad_D1.0mm
U2: TPS629210DRLR; SOT-583-8; MPN TPS629210DRLR; LCSC C5219301
U6, U7: TPS22917DBVR; SOT-23-6; MPN TPS22917DBVR; LCSC C2681320
U8: TPS62933DRLR; SOT-583-8; MPN TPS62933DRLR; LCSC C3200405; not fitted

Connections:
3V3: C5.1, C6.1, C7.1, L1.2, R4.1, TP1.1, U2.3 (VOS), U6.1 (VIN), U7.1 (VIN); also elsewhere on the board
3V3_FP: C11.1, U7.6 (VOUT); also elsewhere on the board
3V3_NFC: C9.1, U6.6 (VOUT); also elsewhere on the board
5V_FACE: C13.1, C14.1, L2.2, R9.1; also elsewhere on the board
BAT: J1.1, Q1.3 (D), R16.1
BAT_ON: Q7.1 (G), Q8.3 (D), R16.2
BAT_SRC: D1.1 (K), Q1.2 (S), Q6.2 (S), R1.2
BST_5V: C12.1, U8.6 (BST)
CC1: J2.A5 (CC1), R2.1
CC2: J2.B5 (CC2), R3.1
CT_FP: C10.1, U7.4 (CT)
CT_NFC: C8.1, U6.4 (CT)
FACE_PWR_EN: R11.1, U8.2 (EN); also elsewhere on the board
FB_3V3: R4.2, R5.1, U2.1 (FB/VSET)
FB_5V: R9.2, R10.1, U8.8 (FB)
FP_PWR_EN: R8.1, U7.3 (ON); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, D2.2 (A2), J1.2, J2.A12 (GND), J2.B12 (GND), J2.S1 (SHIELD), Q3.2 (S), Q7.2 (S), Q8.2 (S), R2.2, R3.2, R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R13.2, R15.2, R17.2, TP3.1, U2.5 (GND), U6.2 (GND), U7.2 (GND), U8.4 (GND); also elsewhere on the board
NFC_PWR_EN: R7.1, U6.3 (ON); also elsewhere on the board
REVPOL_G: D1.2 (A), Q1.1 (G), Q6.1 (G), Q7.3 (D), R1.1
SCONF_3V3: R6.1, U2.8 (MODE/S-CONF)
SS_5V: C16.1, U8.7 (SS)
SW_3V3: L1.1, U2.4 (SW)
SW_5V: C12.2, L2.1, U8.5 (SW)
USB_VBUS: D2.1 (A1), D3.2 (A), J2.A9 (VBUS), J2.B9 (VBUS), Q8.1 (G), R17.1
VBAT_ADC: C17.1, R14.2, R15.1; also elsewhere on the board
VBAT_EN: Q3.1 (G), R13.1; also elsewhere on the board
VBAT_P: C1.1, C2.1, C3.1, C4.1, C15.1, D3.1 (K), Q2.2 (S), Q6.3 (D), R12.1, TP2.1, U2.6 (VIN), U2.7 (EN), U8.3 (VIN); also elsewhere on the board
VDIV_G: Q2.1 (G), Q3.3 (D), R12.2
VDIV_HI: Q2.3 (D), R14.1

Notes on the sheet:
电源树按 board-spec 第 2 节。所有 *_EN 默认 100k 下拉（复位期间支路关断）。 U8 及其外围、J6 为人脸版器件，基础版 DNP。 U2 的 MODE/S-CONF（R6）和 FB/VSET 接法、U8 的 RT 悬空频率请按 TI 数据手册核实。 C1 选低漏电型号：电解电容漏电可能达数 µA~数十 µA，打样后实测睡眠电流，必要时换陶瓷电容组。

Parts:
C20, C30: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C21, C24, C25, C26, C27, C28, C29, C31: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C22: 4.7uF; C_0603_1608Metric; MPN CL10A475KO8NNNC; LCSC C19666
C23: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
J3: DEBUG 2x5 1.27; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN FTSH-105-01-L-DV; LCSC C5199898
L3: 2.2uH; L_0805_2012Metric; MPN LQM21PN2R2MGHL; LCSC C341781
R20: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R21: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
R22: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted
TP4: SWCLK; TestPoint_Pad_D1.0mm
TP5: SWDIO; TestPoint_Pad_D1.0mm
TP6: RESETn; TestPoint_Pad_D1.0mm
TP7: VCOM_TX; TestPoint_Pad_D1.0mm
TP8: VCOM_RX; TestPoint_Pad_D1.0mm
TP9: SWV; TestPoint_Pad_D1.0mm
TP10: TP_PD9; TestPoint_Pad_D1.0mm
TP11: TP_PD10; TestPoint_Pad_D1.0mm
TP12: TP_PD11; TestPoint_Pad_D1.0mm
TP13: TP_PD12; TestPoint_Pad_D1.0mm
TP14: TP_PD13; TestPoint_Pad_D1.0mm
TP15: TP_PD14; TestPoint_Pad_D1.0mm
TP16: TP_PD15; TestPoint_Pad_D1.0mm
U1: EFR32FG28B322F1024IM68-A; QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm_ThermalVias; MPN EFR32FG28B322F1024IM68-A; LCSC C20471554
Y1: 39.0MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; MPN 8Y39072005; LCSC C20248925
Y2: 32.768kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm; MPN Q13FC13500004; LCSC C32346

Connections:
3V3: C20.1, C21.1, C24.1, C25.1, C26.1, C27.1, C28.1, J3.1, R20.2, R22.1, U1.6 (IOVDD), U1.19 (RFVDD), U1.33 (IOVDD), U1.50 (VREGVDD), U1.53 (AVDD), U1.54 (IOVDD); also elsewhere on the board
BUZZER: U1.47 (PA14); also elsewhere on the board
DBL_LOCK: U1.31 (PB00); also elsewhere on the board
DECOUPLE: C23.1, U1.48 (DECOUPLE)
DOOR_HALL: U1.40 (PA07); also elsewhere on the board
DVDD: C22.1, L3.2, R21.1, U1.52 (DVDD)
FACE_PWR_EN: U1.65 (PD05); also elsewhere on the board
FACE_RX: U1.63 (PD07); also elsewhere on the board
FACE_TX: U1.64 (PD06); also elsewhere on the board
FP_PWR_EN: U1.66 (PD04); also elsewhere on the board
FP_RX: U1.67 (PD03); also elsewhere on the board
FP_TOUCH: U1.39 (PA06); also elsewhere on the board
FP_TX: U1.68 (PD02); also elsewhere on the board
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, J3.2, U1.20 (RFVSS), U1.51 (VREGVSS), U1.69 (VSS(EP)), Y1.2, Y1.4; also elsewhere on the board
HFXI: U1.16 (HFXTAL_I), Y1.1
HFXO: U1.17 (HFXTAL_O), Y1.3
KEY_BL_EN: U1.62 (PD08); also elsewhere on the board
KEY_INT: U1.32 (PA00); also elsewhere on the board
KEY_SCL: U1.45 (PA12); also elsewhere on the board
KEY_SDA: U1.46 (PA13); also elsewhere on the board
LED_B: U1.15 (PC11); also elsewhere on the board
LED_G: U1.14 (PC10); also elsewhere on the board
LED_R: U1.26 (PB05); also elsewhere on the board
LFXTAL_I: U1.1 (PD01/LFXTAL_I), Y2.1
LFXTAL_O: U1.2 (PD00/LFXTAL_O), Y2.2
MECH_KEY: U1.44 (PA11); also elsewhere on the board
MOT_IN1: U1.10 (PC06); also elsewhere on the board
MOT_IN2: U1.11 (PC07); also elsewhere on the board
MOT_ISENSE: U1.27 (PB04); also elsewhere on the board
MOT_NSLEEP: U1.12 (PC08); also elsewhere on the board
NFC_CS: U1.7 (PC03); also elsewhere on the board
NFC_IRQ: U1.37 (PA04); also elsewhere on the board
NFC_MISO: U1.5 (PC02); also elsewhere on the board
NFC_MOSI: U1.4 (PC01); also elsewhere on the board
NFC_NRST: U1.8 (PC04); also elsewhere on the board
NFC_PWR_EN: U1.9 (PC05); also elsewhere on the board
NFC_SCK: U1.3 (PC00); also elsewhere on the board
PAVDD: C29.1, C30.1, R21.2, R22.2, U1.25 (PAVDD); also elsewhere on the board
PROX_INT: U1.43 (PA10); also elsewhere on the board
RESETn: C31.1, J3.3, R20.1, TP6.1, U1.18 (RESETn)
RF2G4_I0: U1.22 (RF2G4_I0); also elsewhere on the board
RF2G4_O0: U1.24 (RF2G4_O0); also elsewhere on the board
SETUP_KEY: U1.38 (PA05); also elsewhere on the board
SPARE_WAKE: U1.28 (PB03); also elsewhere on the board
SUBG_I1: U1.21 (SUBG_I1); also elsewhere on the board
SUBG_O1: U1.23 (SUBG_O1); also elsewhere on the board
SWCLK: J3.8, TP4.1, U1.34 (PA01)
SWDIO: J3.7, TP5.1, U1.35 (PA02)
SWV: J3.6, TP9.1, U1.36 (PA03)
TAMPER: U1.30 (PB01); also elsewhere on the board
TP_PD9: TP10.1, U1.61 (PD09)
TP_PD10: TP11.1, U1.60 (PD10)
TP_PD11: TP12.1, U1.59 (PD11)
TP_PD12: TP13.1, U1.58 (PD12)
TP_PD13: TP14.1, U1.57 (PD13)
TP_PD14: TP15.1, U1.56 (PD14)
TP_PD15: TP16.1, U1.55 (PD15)
VBAT_ADC: U1.29 (PB02); also elsewhere on the board
VBAT_EN: U1.13 (PC09); also elsewhere on the board
VCOM_RX: J3.4, TP8.1, U1.42 (PA09)
VCOM_TX: J3.5, TP7.1, U1.41 (PA08)
VREGSW: L3.1, U1.49 (VREGSW)

Notes on the sheet:
去耦、DC-DC 电感、晶振照抄 Silicon Labs xG28 射频板参考设计（BRD4401C）；此处取值为常用值，以参考设计为准。 HFXO/LFXO 使用芯片内部负载电容（Series 2 HFXO/LFXO 内置可调电容），无需外部负载电容。 QFN68 封装选 EP 5.2x5.2 mm 版本，请按数据手册封装图核对散热焊盘尺寸。 J3 引脚按 Mini Simplicity 10 针（AN958）定义：1 VTARGET 2 GND 3 RST 4 VCOM_RX 5 VCOM_TX 6 SWO 7 SWDIO 8 SWCLK 9/10 PTI 不用。

Parts:
ANT1: 433MHz spring; Spring_Antenna_433_THT; MPN 433 MHz 螺旋弹簧天线（手焊）
ANT2: 2.4GHz PCB IFA; Texas_SWRA117D_2.4GHz_Left
C101: 15pF; C_0402_1005Metric; MPN GRM1555C1H150JA01D; LCSC C76950
C102: 5.6pF; C_0402_1005Metric; MPN GRM1555C1H5R6CA01D; LCSC C85941
C105: 220pF; C_0402_1005Metric; MPN GRM1555C1H221JA01D; LCSC C71693
C106, C107: DNP; C_0402_1005Metric; not fitted
C108: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C109: 100pF; C_0402_1005Metric; MPN GRM1555C1H101JA01D; LCSC C77177
C201: 1pF; C_0201_0603Metric; MPN GJM0335C1E1R0BB01D; LCSC C91603
C202: 0.3pF; C_0201_0603Metric; MPN GJM0335C1ER30BB01D; LCSC C237456
C203: DNP; C_0201_0603Metric; not fitted
C204: 20pF; C_0201_0603Metric; MPN GJM0335C1E200GB01D; LCSC C426116
J8: IPEX; U.FL_Hirose_U.FL-R-SMT-1_Vertical; MPN BWIPX-1-001E; LCSC C496552; not fitted
L101: 10nH; L_0402_1005Metric; MPN LQG15HS10NJ02D; LCSC C77103
L102: 33nH; L_0402_1005Metric; MPN LQG15HS33NJ02D; LCSC C86062
L103: 82nH; L_0402_1005Metric; MPN LQG15HS82NJ02D; LCSC C98002
L201: 3nH; L_0201_0603Metric; MPN LQP03TN3N0B02D; LCSC C98044
L202: 8.2nH; L_0201_0603Metric; MPN LQP03TN8N2J02D; LCSC C206407
L203: 3.1nH; L_0201_0603Metric; MPN LQP03TN3N1B02D; LCSC C206428
L204: 1.8nH; L_0201_0603Metric; MPN LQP03TN1N8B02D; LCSC C98040
R101: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
R102: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted

Connections:
ANT_IPEX: J8.1 (In), R102.2
ANT_SPRING: ANT1.1, R101.2
GND: ANT2.2 (Shield), C101.2, C106.2, C107.2, C108.2, C109.2, C201.2, C202.2, C203.2, J8.2 (Ext), L103.2, L204.2; also elsewhere on the board
PAVDD: C108.1, C109.1, L101.2; also elsewhere on the board
RF2G4_I0: L203.1, L204.1; also elsewhere on the board
RF2G4_O0: L201.1; also elsewhere on the board
RF24_A: C201.1, L201.2, L202.1
RF24_ANT: ANT2.1 (A), C203.1, C204.2, L203.2
RF24_B: C202.1, C204.1, L202.2
RF_ANT: C105.2, C107.1, R101.1, R102.1
RF_SUBG: C101.1, C102.2, C105.1, C106.1, L102.2
SUBG_I1: C102.1, L103.1; also elsewhere on the board
SUBG_O1: L101.1, L102.1; also elsewhere on the board

Notes on the sheet:
433 MHz：TX/RX 直连（Direct-Tie）匹配，无射频开关。拓扑和取值由项目方提供，依据 EFR32ZG28 数据手册 5.2.3（Fig 5.7 / Table 5.5） 与 AN923.2 的 433 MHz +14 dBm 匹配网络，生成工程时无法下载原文核对，打样前请对照原文确认一遍。 映射：官方 L1=L101（馈电，接 PAVDD）、L2=L102、C1=C101、C2=C102、L3=L103、C3=C105（原 L106 位）。 +14 dBm 匹配：门锁限 10 mW e.r.p.，传导功率按天线实测设定，不要按 +20 dBm 满功率发射（满功率需另一套匹配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

Parts:
C40: 10nF; C_0402_1005Metric; MPN CL05B103KB5NNNC; LCSC C15195
C41: 10uF/25V; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C42, C43: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
J7: MOTOR; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN); LCSC C295747
R30: 0.22R 1%; R_0603_1608Metric; MPN PE0603FRF070R22L; LCSC C20160538
R31: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R32: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
U3: DRV8837DSGR; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN DRV8837DSGR; LCSC C39159

Connections:
3V3: C43.1, U3.8 (VCC); also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, R30.2, R32.2; also elsewhere on the board
MOT_GND: R30.1, R31.1, U3.4 (GND), U3.9 (GND)
MOT_IN1: U3.6 (IN1); also elsewhere on the board
MOT_IN2: U3.5 (IN2); also elsewhere on the board
MOT_ISENSE: C40.1, R31.2; also elsewhere on the board
MOT_NSLEEP: R32.1, U3.7 (~SLEEP); also elsewhere on the board
MOT_OUT1: J7.1, U3.2 (OUT1)
MOT_OUT2: J7.2, U3.3 (OUT2)
VBAT_P: C41.1, C42.1, U3.1 (VM); also elsewhere on the board

Notes on the sheet:
VM 直接接 VBAT_P；低边 0.22 Ω 采样（MOT_GND），经 1k/10nF 到 PB4。 大电流回路（J7、U3、R30、C41）远离射频和晶振，电机地单点回到电池负极。 U3 散热焊盘 EP 与 GND 脚同接 MOT_GND。
